require u-boot-common_2022.01.inc
require u-boot-mainline-tools.inc
