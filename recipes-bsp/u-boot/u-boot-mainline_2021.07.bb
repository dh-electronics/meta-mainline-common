require u-boot-common_2021.07.inc
require u-boot-mainline.inc

DEPENDS += "bc-native dtc-native"

PROVIDES += "u-boot"
