require u-boot-common_2022.01.inc
require u-boot-mainline.inc

DEPENDS += "bc-native dtc-native"

PROVIDES += "u-boot"
