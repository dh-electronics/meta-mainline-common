require u-boot-common_2020.07.inc
require u-boot-tools.inc
