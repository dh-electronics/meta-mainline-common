require u-boot-common_2021.01.inc
require u-boot-tools.inc
